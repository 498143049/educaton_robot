# Keil uVision project gait_check.uvprojx, settings and files
target gait_check (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gait_check
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ..\Drivers\ESP8266; ..\Drivers\BMX055; ..\Drivers\BSP; ..\Websocket; ..\Network; ..\IMU
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/BSP
    ../Drivers/BSP/: Motor.c Encoder.c
  group Drivers/BMX055
    ../Drivers/BMX055/: bma2x2.c bmg160.c bmm050.c bmx055.c iic.c
  group Drivers/ESP8266
    ../Drivers/ESP8266/: buffer.c esp8266.c esp8266_ll.c
  group Application/Network
    ../Websocket/: my_websocket.c
    ../Src/: my_esp8266.c
  group Application/IMU
    ../IMU/: attitude.c dr.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c SEGGER_RTT.c SEGGER_RTT_printf.c control.c my_logger.c
  group Middlewares/Websocket
    ../Websocket/: websocket.c
software components: CMSIS:CORE 4.1.0
